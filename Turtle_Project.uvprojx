# Keil uVision project Turtle_Project.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: R7FA6T2AB Renesas
  pack: Renesas.RA_DFP.5.5.0
  cpu: IRAM(0x20000000,0x010000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: Turtle_Project +hex
  BeforeMake: cmd /c "start "Renesas" /w cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out"""
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: v6Lang=3 v6LangP=3
  c define: ARM_MATH_CM33 ARM_MATH_FLOAT ARM_MATH_FLOAT32 DISABLEFLOAT16
  c misc: @via/rasc_armclang.via -Wno-unknown-warning-option -Wno-sign-conversion -Wno-conversion -Wno-float-equal
  asm misc: --via=via/rasc_armasm.via
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\script\fsp.scat
  link misc: --via=via/rasc_armlink.via
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c sin(x).xlsx
    ./src/drv/: drv_systick.c drv_systick.h drv_led.c drv_led.h drv_io.c drv_io.h drv_uart.c drv_uart.h drv_uart_cb.c drv_uart_cb.h drv_key.c drv_key.h drv_dac.c drv_dac.h drv_cmp.c drv_cmp.h drv_cmp_cb.c drv_cmp_cb.h drv_pwm.c drv_pwm.h drv_pwm_cb.c drv_pwm_cb.h drv_adc.c drv_adc.h drv_adc_cb.c drv_adc_cb.h drv_hall.c drv_hall.h drv_hall_cb.c drv_hall_cb.h
    ./src/motor/: m_parameter.h m_rotor_angle.c m_rotor_angle.h m_ctrl.c m_ctrl.h m_foc.c m_foc.h m_tick.c m_tick.h m_svpwm.c m_svpwm.h m_current_cal.c m_current_cal.h m_pid.c m_pid.h m_observer.c m_observer.h
    ./src/math/: math_trigonometric.c math_trigonometric.h math_utils.c math_utils.h
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.16.2, Flex Software:RA Configuration 1.0.0
